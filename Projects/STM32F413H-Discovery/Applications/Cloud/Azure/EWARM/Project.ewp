# IAR project Project.ewp, settings and files
configuration STM32F413H_DISCOVERY_Azure (ARM, debug)
  General.OGChipSelectEditMenu: STM32F413ZH ST STM32F413ZH
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F413xx; USE_HAL_DRIVER; USE_STM32F413H_DISCOVERY; MBEDTLS_CONFIG_FILE=<az_mbedtls_config.h>; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; ENABLE_IOT_WARNING; DONT_USE_UPLOADTOBLOB; AZURE; USE_MBED_TLS; EINVAL=22; ENOMEM=12; STM32F413xx; USE_WIFI
  ICCARM.CCDiagSuppress: Pa084,Pe188,Pe177
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F413H-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Log; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Common\Shared\Inc; ..\..\..\..\..\Common\Azure\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\azure-iot-sdk-c\umqtt\inc; ..\..\..\..\..\..\Middlewares\Third_Party\azure-iot-sdk-c\iothub_client\inc; ..\..\..\..\..\..\Middlewares\Third_Party\azure-iot-sdk-c\c-utility\inc; ..\..\..\..\..\..\Middlewares\Third_Party\azure-iot-sdk-c\c-utility\pal\generic; ..\..\..\..\..\..\Middlewares\Third_Party\azure-iot-sdk-c\serializer\inc; ..\..\..\..\..\..\Middlewares\Third_Party\azure-iot-sdk-c\deps\parson; ..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include; ..\..\..\..\..\..\Drivers\BSP\Components\es_wifi
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F413H-Discovery.bin
  ILINK.IlinkOutputFile: STM32F413H-Discovery.out
  ILINK.IlinkIcfFile: stm32f413xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Azure
    ../../../../../Common/Azure/Src/: az_platform_STM32Cube.c az_socketio_mbed.c az_tcpsocketconnection_c_STM32Cube.c az_threadapi_STM32Cube.c az_tickcounter_STM32Cube.c az_tlsio_mbedtls.c azure_base64.c azure_sha1.c azure_version.c AzureXcubeSample.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c flash_f4.c
  group Application/Common
    ../../../../../Common/Shared/Src/: cloud.c entropy_hardware_poll.c heap.c iot_flash_config.c net.c rfu.c STM32CubeRTCInterface.c timingSystem.c timedate.c http_util.c mbedtls_net.c net_tls_mbedtls.c wifi_net.c net_tcp_wifi.c
  group Application/EWARM
    ./: startup_stm32f413xx.s
  group Application/Wifi
    ../Src/: es_wifi_io.c wifi.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_ll_fsmc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-utility
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/src/: buffer.c connection_string_parser.c consolelogger.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c hmac.c hmacsha256.c map.c optionhandler.c sastoken.c sha224.c sha384-512.c singlylinkedlist.c string_tokenizer.c strings.c urlencode.c usha.c vector.c xio.c xlogging.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters/: agenttime.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-iothub_client
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/src/: iothub_client_authorization.c iothub_client_diagnostic.c iothub_client_ll.c iothub_client_retry_control.c iothub_message.c iothubtransport_mqtt_common.c iothubtransportmqtt.c
  group Middlewares/Third_Party/azure-iot-sdk-c/parson
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson/: parson.c
  group Middlewares/Third_Party/azure-iot-sdk-c/serializer
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/src/: agenttypesystem.c codefirst.c commanddecoder.c datamarshaller.c datapublisher.c iotdevice.c jsondecoder.c jsonencoder.c methodreturn.c multitree.c schema.c schemalib.c
  group Middlewares/Third_Party/azure-iot-sdk-c/umqtt
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
