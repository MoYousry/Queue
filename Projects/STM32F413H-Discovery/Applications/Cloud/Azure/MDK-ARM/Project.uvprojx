# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x817FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F413H_Discovery +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F413xx,USE_STM32F413H_DISCO,USE_HAL_DRIVER,EINVAL=-1,ENOMEM=EINVAL,MBEDTLS_CONFIG_FILE=<az_mbedtls_config.h>,ENABLE_IOT_ERROR,ENABLE_IOT_INFO,ENABLE_IOT_WARNING,USE_MBED_TLS,USE_WIFI,AZURE,DONT_USE_UPLOADTOBLOB,STRINGS_C_SPRINTF_BUFFER_SIZE=512
  c misc: --gnu --diag_suppress 177 --diag_suppress 188
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F413H-Discovery;../../../WiFi/Inc;../../../../../../Drivers/BSP/Components/es_wifi;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/pal/generic;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson;../../../../../../Middlewares/Third_Party/mbedTLS/include;../Inc;../../../../../Common/Shared/Inc;../../../../../../Drivers/BSP/Components/vl53l0x;../../../../../Common/Azure/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\STM32F413H_Discovery.sct
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_mmc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_hcd.c stm32f4xx_hal_gpio.c stm32f4xx_hal_nor.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_lptim.c stm32f4xx_ll_usb.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_flash.c stm32f4xx_hal_pccard.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_cec.c stm32f4xx_hal_dac.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_qspi.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal.c stm32f4xx_hal_cryp.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dsi.c stm32f4xx_hal_rng.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_i2s.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_pwr_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_hash.c stm32f4xx_hal_adc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_i2c.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_sram.c stm32f4xx_hal_pcd.c stm32f4xx_hal_smartcard.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters/: agenttime.c
  group Middlewares/Third_Party/azure-iot-sdk-c/parson
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson/: parson.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-utility
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/src/: connection_string_parser.c xlogging.c httpapiex.c buffer.c sha384-512.c doublylinkedlist.c httpheaders.c hmac.c uws_client.c wsio.c singlylinkedlist.c utf8_checker.c sha1.c urlencode.c base64.c strings.c gballoc.c hmacsha256.c map.c crt_abstractions.c string_tokenizer.c constmap.c httpapiexsas.c optionhandler.c xio.c constbuffer.c uws_frame_encoder.c sha224.c vector.c usha.c sastoken.c consolelogger.c gb_rand.c http_proxy_io.c
  group Middlewares/Third_Party/azure-iot-sdk-c/iothub_client
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/src/: iothub_client_ll.c iothubtransport.c iothub_client_ll_uploadtoblob.c iothubtransportmqtt.c version.c iothubtransportmqtt_websockets.c iothub_client_retry_control.c iothubtransport_mqtt_common.c iothub_client.c iothub_message.c iothub_client_authorization.c iothub_client_diagnostic.c blob.c
  group Middlewares/Third_Party/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: x509_crl.c asn1parse.c x509_csr.c ctr_drbg.c md4.c entropy_poll.c memory_buffer_alloc.c ssl_cache.c entropy.c x509write_csr.c pem.c ssl_ciphersuites.c oid.c pk_wrap.c hmac_drbg.c des.c asn1write.c version.c pkcs11.c ssl_cookie.c aes.c rsa.c pkcs12.c ssl_srv.c padlock.c platform.c sha256.c version_features.c md2.c md.c aesni.c threading.c error.c sha1.c ecdh.c ssl_cli.c blowfish.c pkparse.c havege.c ecp.c pkcs5.c gcm.c debug.c x509_crt.c ecjpake.c dhm.c cipher_wrap.c arc4.c pk.c base64.c cmac.c x509write_crt.c pkwrite.c md_wrap.c ripemd160.c md5.c certs.c x509.c timing.c ecp_curves.c bignum.c ecdsa.c xtea.c cipher.c ccm.c ssl_ticket.c ssl_tls.c camellia.c x509_create.c sha512.c
  group Doc
    ../: readme.txt
  group Application/WiFi
    ../Src/: es_wifi_io.c wifi.c
  group Drivers/BSP/ES_WIFI
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Middlewares/Third_Party/azure-iot-sdk-c/umqtt
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/src/: mqtt_codec.c mqtt_message.c mqtt_client.c
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery.c
  group Application/Azure
    ../../../../../Common/Azure/Src/: AzureXcubeSample.c azure_version.c azure_sha1.c az_tlsio_mbedtls.c azure_base64.c az_tickcounter_STM32Cube.c az_platform_STM32Cube.c az_socketio_mbed.c az_tcpsocketconnection_c_STM32Cube.c az_threadapi_STM32Cube.c
  group Application/User
    ../Src/: flash_f4.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
  group Application/Common
    ../../../../../Common/Shared/Src/: net.c net_tcp_wifi.c timingSystem.c entropy_hardware_poll.c wifi_net.c net_tls_mbedtls.c mbedtls_net.c rfu.c http_util.c cloud.c timedate.c iot_flash_config.c STM32CubeRTCInterface.c
  group /MDK-ARM
    ./: startup_stm32f413xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/Third_Party/azure-iot-sdk-c/serializer
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/src/: methodreturn.c codefirst.c dataserializer.c schemalib.c datapublisher.c commanddecoder.c schemaserializer.c multitree.c datamarshaller.c iotdevice.c jsondecoder.c jsonencoder.c schema.c agenttypesystem.c
software components: CMSIS:CORE 5.0.1
