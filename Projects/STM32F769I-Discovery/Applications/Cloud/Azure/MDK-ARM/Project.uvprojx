# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I_Discovery +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,HAS_RTOS,USE_LWIP,USE_MBED_TLS,MBEDTLS_CONFIG_FILE=<az_mbedtls_config.h>,ENABLE_IOT_ERROR,ENABLE_IOT_INFO,ENABLE_IOT_WARNING,AZURE,DONT_USE_UPLOADTOBLOB,STRINGS_C_SPRINTF_BUFFER_SIZE=512
  c misc: --gnu  --diag_suppress 177 --diag_suppress 188
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/pal/generic;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Utilities;../../../../../../Utilities/Fonts;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Utilities/Log;../../../../../Common/Azure/Inc;..\..\..\..\..\Common\Shared\Inc
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\STM32F769I_Discovery.sct
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/azure-iot-sdk-c/serializer
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/src/: schema.c schemalib.c datapublisher.c multitree.c methodreturn.c commanddecoder.c dataserializer.c codefirst.c jsondecoder.c jsonencoder.c schemaserializer.c agenttypesystem.c datamarshaller.c iotdevice.c
  group Middlewares/azure-iot-sdk-c/umqtt
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/src/: mqtt_client.c mqtt_message.c mqtt_codec.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: sha1.c platform.c debug.c entropy.c havege.c des.c ccm.c pk_wrap.c md4.c error.c base64.c pem.c oid.c x509write_crt.c x509_create.c x509_crt.c version.c ssl_ticket.c blowfish.c pkcs5.c aes.c timing.c aesni.c pkcs11.c ecp_curves.c entropy_poll.c bignum.c x509_csr.c x509_crl.c ctr_drbg.c ecjpake.c ripemd160.c ssl_ciphersuites.c xtea.c memory_buffer_alloc.c ssl_tls.c sha512.c x509write_csr.c asn1write.c ecp.c md5.c md_wrap.c ssl_cli.c hmac_drbg.c gcm.c pkparse.c cipher.c x509.c pkwrite.c dhm.c ssl_cookie.c padlock.c ssl_cache.c camellia.c asn1parse.c arc4.c ecdsa.c sha256.c ssl_srv.c ecdh.c cmac.c threading.c md.c pkcs12.c version_features.c certs.c pk.c rsa.c cipher_wrap.c md2.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/azure-iot-sdk-c/c-utility
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/src/: strings.c uws_client.c sha384-512.c singlylinkedlist.c xio.c httpheaders.c gb_rand.c sha224.c buffer.c sastoken.c gballoc.c sha1.c uws_frame_encoder.c hmac.c constbuffer.c wsio.c connection_string_parser.c utf8_checker.c usha.c doublylinkedlist.c base64.c optionhandler.c urlencode.c hmacsha256.c string_tokenizer.c crt_abstractions.c gb_stdio.c gb_time.c http_proxy_io.c xlogging.c constmap.c consolelogger.c vector.c httpapiexsas.c map.c httpapiex.c
  group Drivers/BSP/STM32F769I_Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c
  group Middlewares/LwIP/Core/IPV4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip4.c dhcp.c igmp.c autoip.c icmp.c etharp.c ip4_frag.c
  group Application/Azure
    ../../../../../Common/Azure/Src/: azure_version.c az_threadapi_STM32Cube.c az_platform_STM32Cube.c az_socketio_mbed.c az_tcpsocketconnection_c_STM32Cube.c AzureXcubeSample.c azure_base64.c azure_sha1.c az_tlsio_mbedtls.c az_tickcounter_STM32Cube.c
  group Middlewares/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: raw.c inet_chksum.c tcp.c udp.c timeouts.c mem.c tcp_in.c init.c def.c netif.c stats.c dns.c tcp_out.c memp.c ip.c pbuf.c sys.c
  group Middlewares/azure-iot-sdk-c/iothub_client
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/src/: iothubtransport_mqtt_common.c iothub_client_authorization.c iothub_client_diagnostic.c version.c iothub_client_ll.c iothubtransportmqtt_websockets.c iothub_client_retry_control.c iothub_client_ll_uploadtoblob.c iothubtransportmqtt.c iothub_message.c iothubtransport.c iothub_client.c blob.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netbuf.c sockets.c api_lib.c tcpip.c netdb.c api_msg.c netifapi.c err.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dsi.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rng.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_cryp.c stm32f7xx_ll_fmc.c stm32f7xx_hal_eth.c stm32f7xx_hal_tim.c stm32f7xx_hal_rcc.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_hash.c
  group Utilities/Log
    ../../../../../../Utilities/Log/: lcd_log.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c event_groups.c timers.c queue.c croutine.c list.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User
    ../Src/: flash_f7.c main.c ethernetif.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Middlewares/azure-iot-sdk-c/c-utility/adapters
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters/: agenttime.c
  group Application/Common
    ../../../../../Common/Shared/Src/: net.c heap.c STM32CubeRTCInterface.c mbedtls_net.c timingSystem.c cloud.c entropy_hardware_poll.c http_util.c iot_flash_config.c lwip_net.c net_tcp_lwip.c net_tls_mbedtls.c rfu.c timedate.c
  group Middlewares/azure-iot-sdk-c/parson
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson/: parson.c
software components: CMSIS:CORE 5.1.2
